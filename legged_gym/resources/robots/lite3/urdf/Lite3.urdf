Commit message: update depth deploy

File: legged_gym/resources/robots/lite3/urdf/Lite3.urdf (robot description, URDF)
Before this commit: robot Lite3, 20 links, 19 joints
Joints:
- joint depth_camera_joint: origin xyz=0.25228 -0.0005 0.06410 rpy=0 0 0 -> xyz=0.25228 -0.0005 0.07410 rpy=0 0 0
